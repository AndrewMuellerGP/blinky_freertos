# IAR project blinky_FreeRTOS_pca10056.ewp, settings and files
configuration nrf52840_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; FREERTOS; NRF52840_XXAA; ALLOW_PARSING__TEMPLATE; ALLOW_PARSING__JSON; DEBUG_NRF
  ICCARM.CCIncludePath2: ..\..\..\config; ..\..\..\components; ..\..\..\components\boards; ..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\components\libraries\atomic; ..\..\..\components\libraries\balloc; ..\..\..\components\libraries\bsp; ..\..\..\components\libraries\button; ..\..\..\components\libraries\experimental_section_vars; ..\..\..\components\libraries\log; ..\..\..\components\libraries\log\src; ..\..\..\components\libraries\memobj; ..\..\..\components\libraries\ringbuf; ..\..\..\components\libraries\strerror; ..\..\..\components\libraries\timer; ..\..\..\components\libraries\util; ..\..\..\components\toolchain\cmsis\include; ..\..\..\; ..\..\..\external\fprintf; ..\..\..\external\freertos\config; ..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\external\freertos\source\include; ..\..\..\integration\nrfx; ..\..\..\integration\nrfx\legacy; ..\..\..\modules\nrfx; ..\..\..\modules\nrfx\drivers\include; ..\..\..\modules\nrfx\hal; ..\..\..\modules\nrfx\mdk; ..\..\..\pca10056\blank\config; ..\..\..\; C:\TI\simplelink_cc32xx_sdk_4_10_00_07\source\ti\utils\json; C:\TI\simplelink_cc32xx_sdk_4_10_00_07\source\ti\posix\iar
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10056; CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; FREERTOS; NRF52840_XXAA
  AARM.AUserIncludes: ..\..\..\config; ..\..\..\..\..\..\components; ..\..\..\..\..\..\components\boards; ..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; ..\..\..\..\..\..\components\libraries\atomic; ..\..\..\..\..\..\components\libraries\balloc; ..\..\..\..\..\..\components\libraries\bsp; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\experimental_section_vars; ..\..\..\..\..\..\components\libraries\log; ..\..\..\..\..\..\components\libraries\log\src; ..\..\..\..\..\..\components\libraries\memobj; ..\..\..\..\..\..\components\libraries\ringbuf; ..\..\..\..\..\..\components\libraries\strerror; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\toolchain\cmsis\include; ..\..\..; ..\..\..\..\..\..\external\fprintf; ..\..\..\..\..\..\external\freertos\config; ..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52; ..\..\..\..\..\..\external\freertos\portable\IAR\nrf52; ..\..\..\..\..\..\external\freertos\source\include; ..\..\..\..\..\..\integration\nrfx; ..\..\..\..\..\..\integration\nrfx\legacy; ..\..\..\..\..\..\modules\nrfx; ..\..\..\..\..\..\modules\nrfx\drivers\include; ..\..\..\..\..\..\modules\nrfx\hal; ..\..\..\..\..\..\modules\nrfx\mdk; ..\config
  OBJCOPY.OOCOutputFile: blinky_FreeRTOS_pca10056.hex
  ILINK.IlinkOutputFile: blinky_FreeRTOS_pca10056.out
  ILINK.IlinkIcfFile: blinky_FreeRTOS_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../: json_test.c json_test.h main.c simplelink_Callbacks.c simplelink_structures.h
    ../config/: sdk_config.h
  group Board Definition
    ../../../components/boards/: boards.c
  group Board Support
    ../../../components/libraries/bsp/: bsp.c
  group None
    ../../../modules/nrfx/mdk/: iar_startup_nrf52840.s system_nrf52840.c
  group nRF_Drivers
    ../../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c nrf_drv_spi.h
    ../../../components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../modules/nrfx/soc/: nrfx_atomic.c
    ../../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_spi.c nrfx_spim.c
  group nRF_Libraries
    ../../../components/libraries/button/: app_button.c
    ../../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../components/libraries/timer/: app_timer_freertos.c
    ../../../components/libraries/atomic/: nrf_atomic.c
    ../../../components/libraries/balloc/: nrf_balloc.c
    ../../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../components/libraries/memobj/: nrf_memobj.c
    ../../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../components/libraries/strerror/: nrf_strerror.c
  group nRF_Log
    ../../../components/libraries/log/src/: nrf_log_frontend.c nrf_log_str_formatter.c
  group Third Parties
    ../../../external/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../external/freertos/source/portable/MemMang/: heap_4.c
    ../../../external/freertos/portable/IAR/nrf52/: port.c
    ../../../external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group Third Parties/cJSON
    ../../../external/cJSON/: cJSON.c cJSON.h
  group Third Parties/dpl
    ../../../dpl/: ClockP_freertos.c DebugP_freertos.c HwiPMSP430_freertos.c MutexP_freertos.c PowerMSP430_freertos.c SemaphoreP_freertos.c SystemP_freertos.c
  group Third Parties/posix/freertos
    ../../../../../TI/simplelink_cc32xx_sdk_4_10_00_07/source/ti/posix/freertos/: clock.c memory.c mqueue.c Mtx.h pthread.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c PTLS.h reent.c sched.c semaphore.c sleep.c timer.c
    ../../../../../TI/simplelink_msp432p4_sdk_3_40_01_02/source/ti/posix/freertos/: Mtx.c
  group Third Parties/posix/iar
    ../../../../../TI/simplelink_cc32xx_sdk_4_10_00_07/source/ti/posix/iar/: errno.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h
  group Third Parties/posix/iar/sys
    ../../../../../TI/simplelink_cc32xx_sdk_4_10_00_07/source/ti/posix/iar/sys/: _internal.h time.h types.h
  group Third Parties/TI/drivers/wifi
    ../../../ti/drivers/net/wifi/: device.h errors.h eventreg.c eventreg.h fs.h Makefile netapp.h netcfg.h netutil.h simplelink.h sl_socket.h slnetifwifi.h trace.h wlan.h wlanconfig.h
  group Third Parties/TI/drivers/wifi/porting
    ../../../ti/drivers/net/wifi/porting/: cc_pal.c cc_pal.h SIMPLELINKWIFI.h user.h
  group Third Parties/TI/drivers/wifi/source
    ../../../ti/drivers/net/wifi/source/: device.c driver.c driver.h flowcont.c flowcont.h fs.c netapp.c netcfg.c netutil.c nonos.c nonos.h objInclusion.h protocol.h sl_socket.c spawn.c spawn.h wlan.c wlanconfig.c
  group Third Parties/TI_JSON
    ../../../../../TI/simplelink_msp432p4_sdk_3_40_01_02/source/ti/utils/json/source/: json.c json_engine.c parse_common.c utils.c
