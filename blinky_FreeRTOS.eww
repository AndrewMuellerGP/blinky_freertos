<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\pca10056\blank\iar\blinky_FreeRTOS_pca10056.ewp</path>
    </project>
    <batchBuild />
</workspace>
